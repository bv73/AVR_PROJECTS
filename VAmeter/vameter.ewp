# IAR project vameter.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: _SYSTEM_BUILD; FRMWRI_BUFSIZE=32; QSORT_MAXSIZE=32; SCANF_MAXLINE=32
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x120
  General.GenDeviceSelectMenu: m88pa ATmega88PA
  ICCAVR.CCDefines: _SYSTEM_BUILD; FRMWRI_BUFSIZE=32; QSORT_MAXSIZE=32; SCANF_MAXLINE=32; NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm88pa.xcl
  group (top)
    ./: main.c
